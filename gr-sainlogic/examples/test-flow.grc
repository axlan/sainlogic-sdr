options:
  parameters:
    author: axlan
    generate_options: qt_gui
    id: sainlogic_test
    output_language: python
    title: Sainlogic Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433.92e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: sainlogic_sainlogic_decode_0
  id: sainlogic_sainlogic_decode
  parameters:
    fs: samp_rate
    threshold: '.01'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', sainlogic_sainlogic_decode_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
